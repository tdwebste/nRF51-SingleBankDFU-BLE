# Keil uVision project bootloader.uvproj, settings and files
target dfu_single_bank_ble (s110) (ARM-ADS)
  device: nRF51822_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.1.0.3
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: bootloader +hex
  c flags: Optim=4 wLevel=2
  c define: NRF51,DEBUG_NRF_USER, BOOTLOADER_BANKED BLE_STACK_SUPPORT_REQD
  c misc: --c99
  c include: ..;..\include;..\include\ble_transport;..\..\..\nordic\Nordic\nrf51822\Include;..\..\..\nordic\Nordic\nrf51822\Include\sd_common;..\..\..\nordic\Nordic\nrf51822\Include\app_common;..\..\..\nordic\Nordic\nrf51822\Include\ble;..\..\..\nordic\Nordic\nrf51822\Include\ble\ble_services;..\..\..\nordic\Nordic\nrf51822\Include\s110;..\..\..\SofM\include;..\..\..\SofM\include
  memory RVCT4: ROM 0x3c000 size 0x4000
  memory RVCT9: RAM 0x20002000 size 0x2000
  group Startup Code
    ./../../../nordic/Nordic/nrf51822/Source/templates/: system_nrf51.c
    ../: arm_startup_nrf51.s
  group Source Code
    ./../: main.c
    ../: dfu_single_bank.c bootloader.c bootloader_util_arm.c
    ../../../SofM/src/: led_lib.c
  group Services
    ../../../nordic/Nordic/nrf51822/Source/ble/ble_services/: ble_dfu.c
  group Libraries
    ../../../nordic/Nordic/nrf51822/Source/app_common/: app_timer.c app_scheduler.c app_gpiote.c crc16.c pstorage.c
    ../../../nordic/Nordic/nrf51822/Source/sd_common/: softdevice_handler.c
  group HCI Transport
    ../../../nordic/Nordic/nrf51822/Source/app_common/: hci_mem_pool.c
  group BLE Transport
    ../: dfu_transport_ble.c
    ../../../nordic/Nordic/nrf51822/Source/ble/: ble_conn_params.c ble_advdata.c
    ../../../nordic/Nordic/nrf51822/Source/ble/ble_services/: ble_srv_common.c
